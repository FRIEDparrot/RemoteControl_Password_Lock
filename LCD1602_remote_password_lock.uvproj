# Keil uVision project LCD1602_remote_password_lock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD1602_remote_password_lock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\public;.\UART;.\IRED;.\LCD1602
  group Source Group 1
    ./: STARTUP.A51 main.c
  group public
    ./public/: public.c
  group IRED
    ./IRED/: IRED_controller.c
  group LCD1602
    ./LCD1602/: LCD1602_func.c
